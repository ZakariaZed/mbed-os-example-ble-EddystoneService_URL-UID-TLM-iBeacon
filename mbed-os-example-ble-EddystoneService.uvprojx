# Keil uVision project mbed-os-example-ble-EddystoneService.uvprojx, settings and files
target mbed-os-example-ble-EddystoneService (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mbed-os-example-ble-EddystoneService +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NDEBUG
  c misc: -DNRF52_PAN_36 -DDEVICE_RTC=1 -DNRF52_PAN_12 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DNRF52_PAN_15 -DNRF52_PAN_30 -DTARGET_NRF5 --preinclude=mbed_config.h -DCONFIG_GPIO_AS_PINRESET -DBOARD_PCA10040 -D__ASSERT_MSG --no_rtti --split_sections -DCMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" -DDEVICE_PORTINOUT=1 -DSOFTDEVICE_PRESENT -DMBED_BUILD_TIMESTAMP=1515428664.34 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DCMSIS_VECTAB_VIRTUAL -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_MCU_NRF52 -DTARGET_CORTEX_M -DNRF52_PAN_63 -DDEVICE_ERROR_PATTERN=1 -DDEVICE_PORTIN=1 -DARM_MATH_CM4 --apcs=interwork -DTARGET_MCU_NRF52832 -DNRF52_PAN_20 -DDEVICE_I2C=1 -DBLE_STACK_SUPPORT_REQD -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DTARGET_NRF52_COMMON -DTOOLCHAIN_ARM -DNRF52 -DSWI_DISABLE0 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 -DS132 --gnu -DTARGET_NRF52_DK -D__FPU_PRESENT=1 -DDEVICE_SPI=1 -D__MBED__=1 -DNRF52_PAN_31 -DFEATURE_BLE=1 -DTARGET_NORDIC -DNRF52_PAN_62 -DNRF52_PAN_64 -DNRF52_PAN_54 -DNRF52_PAN_55 -DTARGET_M4 -DTARGET_NRF52832 -DNRF52_PAN_51 -DNRF52_PAN_53 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DNRF52_PAN_58 -D__MBED_CMSIS_RTOS_CM -DTARGET_SDK11
  c include: .; img; shields; source; source/PersistentStorageHelper; source/PersistentStorageHelper/nrfPersistentStorageHelper; mbed-os/.; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/mbedtls/targets; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/features/netsocket/cellular; mbed-os/features/netsocket/cellular/generic_modem_driver; mbed-os/features/netsocket/cellular/utils; mbed-os/features/filesystem; mbed-os/features/filesystem/bd; mbed-os/features/filesystem/fat; mbed-os/features/filesystem/fat/ChaN; mbed-os/cmsis; mbed-os/cmsis/TARGET_CORTEX_M; mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_ARM; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/rtx4; mbed-os/rtos/rtx5; mbed-os/rtos/rtx5/TARGET_CORTEX_M; mbed-os/rtos/rtx5/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; mbed-os/rtos/rtx5/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_NORDIC; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/TARGET_NRF52_DK; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk_patch; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device/TOOLCHAIN_ARM_STD; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/pwm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/saadc; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/nrf52; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/hex; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_NRF52_COMMON; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler; mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/porting_tools; mbed-os/features/FEATURE_BLE; mbed-os/features/FEATURE_BLE/ble; mbed-os/features/FEATURE_BLE/ble/services; mbed-os/features/FEATURE_BLE/source; mbed-os/features/FEATURE_BLE/source/services; mbed-os/features/FEATURE_BLE/targets; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/custom; mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/common
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DCMSIS_VECTAB_VIRTUAL,-DNRF52,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_58,-DNRF52_PAN_55,-DNRF52_PAN_54,-DNRF52_PAN_31,-DNRF52_PAN_30,-DNRF52_PAN_51,-DNRF52_PAN_36,-DNRF52_PAN_53,-DTARGET_NRF52832,-D__CORTEX_M4,-DNRF52_PAN_63,-DCONFIG_GPIO_AS_PINRESET,-DBLE_STACK_SUPPORT_REQD,-DSWI_DISABLE0,-DNRF52_PAN_20,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52_PAN_62,-DS132,-DARM_MATH_CM4
  asm include: as above
  memory RVCT4: ROM 0x1b000 size 0x250000
  memory RVCT9: RAM 0x20001870 size 0x6790
  scatter file: mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device/TOOLCHAIN_ARM_STD/nRF52832.sct
  link misc: --show_full_path
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_NRF52_COMMON/: analogin_api.c pwmout_api.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/softdevice/common/softdevice_handler/: ant_stack_handler_types.h app_ram_base.h ble_stack_handler_types.h softdevice_handler.c softdevice_handler.h softdevice_handler_appsh.c softdevice_handler_appsh.h
    mbed-os/features/netsocket/cellular/utils/: APN_db.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h common.h nordic_common.h nrf_assert.c nrf_assert.h nrf_log.c nrf_log.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/pwm/: app_pwm.c app_pwm.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/scheduler/: app_scheduler.c app_scheduler.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/trace/: app_trace.c app_trace.h
    mbed-os/cmsis/: arm_math.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/FEATURE_BLE/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
    mbed-os/features/FEATURE_BLE/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    mbed-os/features/FEATURE_BLE/ble/: BLE.h blecommon.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h deprecate.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/common/: ble_advdata.c ble_advdata.h ble_conn_params.h ble_conn_state.c ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.c ble_srv_common.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_advertising/: ble_advertising.c ble_advertising.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_db_discovery/: ble_db_discovery.c ble_db_discovery.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c ble_debug_assert_handler.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_dtm/: ble_dtm.c ble_dtm.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_error_log/: ble_error_log.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ble_flash/: ble_flash.c ble_flash.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_racp/: ble_racp.c ble_racp.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/ble_radio_notification/: ble_radio_notification.c ble_radio_notification.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/: bootloader.h bootloader_settings.h bootloader_types.h bootloader_util.c bootloader_util.h dfu.h dfu_app_handler.c dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_init_template.c dfu_transport.h dfu_types.h
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/: btle.cpp btle.h btle_clock.h btle_discovery.cpp btle_discovery.h btle_gap.cpp btle_gap.h btle_security.cpp btle_security.h btle_security_pm.cpp
    mbed-os/features/filesystem/fat/ChaN/: ccsbcs.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h system_nrf52.c system_nrf52.h
    mbed-os/cmsis/TARGET_CORTEX_M/TOOLCHAIN_ARM/: cmsis_armcc.h cmsis_armclang.h
    mbed-os/cmsis/TARGET_CORTEX_M/: cmsis_compiler.h
    mbed-os/rtos/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/rtx5/TARGET_CORTEX_M/: cmsis_os2.h core_cm.h rt_OsEventObserver.c rt_OsEventObserver.h RTX_Config.c RTX_Config.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_evr.h rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_os.h rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/: common_rtc.h flash_api.c gpio_api.c gpio_object.h i2c_api.c irq_handlers_hw.h lp_ticker.c nordic_critical.c nrf5x_lf_clk_helper.h objects.h pinmap.c port_api.c reloc_vector_table.c rtc_api.c serial_api.c sleep.c spi_api.c trng_api.c us_ticker.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf52.h nrf52_bitfields.h nrf52_name_change.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/crc16/: crc16.c crc16.h
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/btle/custom/: custom_helper.cpp custom_helper.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/TARGET_NRF52_DK/: device.h PinNames.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/: device_manager.h device_manager_peripheral.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/device_manager/config/: device_manager_cnfg.h
    mbed-os/features/FEATURE_BLE/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/: fds.c fds.h fds_internal_defs.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fds/config/: fds_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/: fstorage.c fstorage.h fstorage_internal_defs.h fstorage_nosd.c
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/fstorage/config/: fstorage_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/ble/peer_manager/: gatt_cache_manager.c gatt_cache_manager.h gattc_cache_manager.c gattc_cache_manager.h gatts_cache_manager.c gatts_cache_manager.h id_manager.c id_manager.h peer_data.c peer_data.h peer_data_storage.c peer_data_storage.h peer_database.c peer_database.h peer_id.c peer_id.h peer_manager.c peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.c pm_buffer.h pm_mutex.c pm_mutex.h security_dispatcher.c security_dispatcher.h security_manager.c security_manager.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/: hci_mem_pool.c hci_mem_pool.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h hci_transport_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/hci/config/: hci_mem_pool_internal.h hci_transport_config.h
    mbed-os/rtos/rtx5/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: irq_cm4f.S
    mbed-os/rtos/: Mail.h mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/targets/TARGET_NORDIC/: mbed_rtx.h
    mbed-os/rtos/rtx5/: mbed_rtx_conf.h mbed_rtx_handlers.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/FEATURE_BLE/targets/TARGET_NORDIC/TARGET_NRF5/source/: nRF5xCharacteristicDescriptorDiscoverer.cpp nRF5xCharacteristicDescriptorDiscoverer.h nRF5xDiscoveredCharacteristic.cpp nRF5xDiscoveredCharacteristic.h nRF5xGap.cpp nRF5xGap.h nRF5xGattClient.cpp nRF5xGattClient.h nRF5xGattServer.cpp nRF5xGattServer.h nRF5xn.cpp nRF5xn.h nRF5xSecurityManager.h nRF5xServiceDiscovery.cpp nRF5xServiceDiscovery.h projectconfig.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/hal/: nrf_adc.c nrf_adc.h nrf_clock.h nrf_ecb.c nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.c nrf_nvmc.h nrf_pdm.h nrf_ppi.h nrf_pwm.h nrf_rtc.h nrf_saadc.c nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_uart.h nrf_wdt.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/: nrf_ble.h nrf_ble_err.h nrf_ble_gap.h nrf_ble_gatt.h nrf_ble_gattc.h nrf_ble_gatts.h nrf_ble_hci.h nrf_ble_l2cap.h nrf_ble_ranges.h nrf_ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/delay/: nrf_delay.c nrf_delay.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/clock/: nrf_drv_clock.c nrf_drv_clock.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/common/: nrf_drv_common.c nrf_drv_common.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/: nrf_drv_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/config/: nrf_drv_config_validation.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/gpiote/: nrf_drv_gpiote.c nrf_drv_gpiote.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/ppi/: nrf_drv_ppi.c nrf_drv_ppi.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/pwm/: nrf_drv_pwm.c nrf_drv_pwm.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/driver_nrf/saadc/: nrf_drv_saadc.c nrf_drv_saadc.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_master/: nrf_drv_spi.c nrf_drv_spi.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/spi_slave/: nrf_drv_spis.c nrf_drv_spis.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/timer/: nrf_drv_timer.c nrf_drv_timer.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk/softdevice/s132/headers/nrf52/: nrf_mbr.h
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/: PeripheralNames.h PortNames.h
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/: pstorage.c pstorage.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/drivers_nrf/pstorage/config/: pstorage_platform.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/sdk_patch/: sdk_config.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_SDK11/libraries/experimental_section_vars/: section_vars.h
    mbed-os/targets/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF52832/device/TOOLCHAIN_ARM_STD/: startup_nrf52832.S sys.cpp
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group mbed-os-example-ble-EddystoneService
    ./: mbed_config.h
  group source
    source/: AuthentificationService.h BatteryService.h EddystoneService.cpp EddystoneService.h EddystoneTypes.h iBeacon.cpp iBeacon.h main.cpp TLMFrame.cpp TLMFrame.h UIDFrame.cpp UIDFrame.h URLFrame.cpp URLFrame.h
    source/PersistentStorageHelper/: ConfigParamsPersistence.cpp ConfigParamsPersistence.h
    source/PersistentStorageHelper/nrfPersistentStorageHelper/: nrfConfigParamsPersistence.cpp
